# Keil uVision project Drift.uvproj, settings and files
target Drift (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: Drift
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=1
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s ST7735.c LCD.s Print.s IO.c RacingCourse1.c Timer0A.c DriftMain.c ADC.c Graphics.c TextDraw.c TExaS.h texas.o Menu1.c Menu2.c RacingCourse2.c FiFo.c UART.c FiFo.h UART.h
